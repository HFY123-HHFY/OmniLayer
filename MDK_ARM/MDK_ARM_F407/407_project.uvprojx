# Keil uVision project 407_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 407_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\..\Drivers\Drivers_STM32F4\Start;..\..\SYSTEM\F407_SYS;..\..\Core\STM32F407\inc;..\..\Enroll;..\..\BSP\LED;..\..\app\Control_Task
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ../../Drivers/Drivers_STM32F4/Start/: startup_stm32f40_41xxx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group sys
    ../../SYSTEM/F407_SYS/: f407_sys.c
  group Core
    ../../Core/STM32F407/src/: f407_gpio.c
  group Enroll
    ../../Enroll/: 407_hw_config.h Enroll.c
  group BSP
    ../../BSP/LED/: LED.c LED.h
  group app
    ../../app/: main.c
    ../../app/Control_Task/: Control_Task.c
