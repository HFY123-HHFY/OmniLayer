# Keil uVision project 103_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 103_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Drivers\Drivers_STM32F1\Start;..\..\SYSTEM\F103_SYS;..\..\Core\STM32F103\inc;..\..\Enroll;..\..\BSP\LED;..\..\app\Control_Task
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../../Drivers/Drivers_STM32F1/Start/: startup_stm32f10x_md.s core_cm3.c system_stm32f10x.c
  group sys
    ../../SYSTEM/F103_SYS/: f103_sys.c f103_sys.h
  group Core
    ../../Core/STM32F103/src/: f103_gpio.c
  group Enroll
    ../../Enroll/: 103_hw_config.h Enroll.c
  group BSP
    ../../BSP/LED/: LED.c
  group app
    ../../app/: main.c
    ../../app/Control_Task/: Control_Task.c
